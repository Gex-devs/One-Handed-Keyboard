# Repository Gex-devs/One-Handed-Keyboard

## KiCad design Hardware/ExternalMouseBall/ProPrj_HTXStudio_OneHanded_Keyboard.kicad_pcb

Board: 2 copper layers, 26.0 x 26.0 mm, 20 parts (0 on the bottom side), 14 nets.

Parts:
C10, C12, C13, C15, C17, C19: C0603
C11, C18: CASE-A_3216
C14, C16, C20: CAP-SMD_L3.2-W1.6-RD-C7171
D10, D11, D12: SOD-323_L1.8-W1.3-LS2.5-RD
FPC10: FPC-SMD_8P-P0.50_XUNPU_FPC-05FB-8PH20
Q10: SOT-416_L1.6-W0.8-P1.00-LS1.6-BR
R10, R11, R12: R0603
U10: ADNS-9800

Connections:
$1N1257: C12.1, U10.8, U10.16
$1N1258: C12.2, Q10.3, U10.1
$1N1260: Q10.1, U10.2
$1N1262: C15.2, C16.1, U10.13
+3.3V: C10.1, C11.1, C13.2, C14.1, C17.2, C18.1, C19.1, C20.1, FPC10.1, Q10.2, U10.9, U10.10, U10.12, U10.15
ADNS9800_CS: FPC10.7, R12.2
ADNS9800_MOTION: FPC10.8, U10.7
GND: C10.2, C11.2, C13.1, C14.2, C15.1, C16.2, C17.1, C18.2, C19.2, C20.2, D10.2, D11.2, D12.2, FPC10.2, FPC10.3, U10.11, U10.14
MISO: FPC10.5, U10.4
MOSI: D10.1, R10.1, U10.6
NCS: D12.1, R12.1, U10.3
SCLK: D11.1, R11.1, U10.5
SPI_MOSI: FPC10.4, R10.2
SPI_SCK: FPC10.6, R11.2

## KiCad design Hardware/ExternalTypeC/ProPrj_HTXStudio_OneHanded_Keyboard.kicad_pcb

Board: 2 copper layers, 21.7 x 14.0 mm, 9 parts (0 on the bottom side), 9 nets.

Parts:
C1, C2: C0402
D2: SOD-523_L1.2-W0.8-LS1.6-BI
FPC10: FPC-SMD_8P-P0.50_XUNPU_FPC-05FB-8PH20
L1: TDFN-6_L1.4-W1.2-P0.40-BL
R6, R7, R9: R0402
USB1: USB-C-SMD_TYPE-C-6PIN-2MD-073

Connections:
$1N2982: R6.2, USB1.4
$1N2983: R7.2, USB1.10
$1N13714: C2.2, R9.2, USB1.13, USB1.14
GND: C1.1, C2.1, D2.2, FPC10.1, FPC10.4, FPC10.5, FPC10.9, FPC10.10, L1.3, L1.4, R6.1, R7.1, R9.1, USB1.1, USB1.12
USB_DM: L1.2, USB1.5, USB1.7
USB_DM_FPC: FPC10.2, L1.5
USB_DP: L1.1, USB1.6, USB1.8
USB_DP_FPC: FPC10.3, L1.6
VBUS: C1.2, D2.1, FPC10.6, FPC10.7, FPC10.8, USB1.2, USB1.11

## KiCad design Hardware/ExternalScroll/ProPrj_HTXStudio_OneHanded_Keyboard.kicad_pcb

Board: 2 copper layers, 25.0 x 25.0 mm, 4 parts (2 on the bottom side), 6 nets.

Parts:
D59: SOD-323_L1.8-W1.3-LS2.5-RD
FPC9: FPC-SMD_8P-P0.50_XUNPU_FPC-05FB-8PH20
SW6: SW-TH_EC10EXXXXXXX
SW8: SW-SMD_4P-L4.5-W4.5-P3.00-LS7.0

Connections:
$1N347: D59.2, SW8.4
CCOL1: D59.1, FPC9.7
CROW6: FPC9.8, SW8.1
ENCODER_A: FPC9.2, SW6.A
ENCODER_B: FPC9.1, SW6.B
GND: FPC9.3, FPC9.4, SW6.4, SW6.5, SW6.C

## KiCad design Hardware/RightHanded/ProPrj_HTXStudio_OneHanded_Keyboard.kicad_pcb

Parts:
11, 21, 31, 41, 51, 61, 71, 81, 91, 101, 111, 121, 131, 141, 151, 161, 171, 181, 191, 201, 211, 221, 231, 241, 251, 261, 271, 281, 291: (no value)
C157, C158, C159, C160, C161, C162, C163, C164, C167: 100nF; C0402; Manufacturer Part CL05B104KB54PNC; LCSC Part Name 100nF ±10% 50V
C165, C166, C168, C169: 1uF; C0402; Manufacturer Part CL05A105KA5NQNC; LCSC Part Name 1uF ±10% 25V
C170, C173: 6pF
C171, C172: 20pF
D159: ESD5Z3V3
FPC100, FPC101, FPC102, FPC103: FPC-05FB-8PH20; FPC-SMD_8P-P0.50_XUNPU_FPC-05FB-8PH20; Manufacturer Part FPC-05FB-8PH20; LCSC Part Name 间距:0.5mm P数:8P 翻盖式 双侧触点/上下接
H100: PZ127V-11-04-0720; HDR-TH_4P-P1.27-V-M; Manufacturer Part PZ127V-11-04-0720; LCSC Part Name 间距:1.27mm 1x4P 直插
LDO100: ME6211C33M5G-N; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BL; Manufacturer Part ME6211C33M5G-N; LCSC Part Name 输入6V 输出3.3V 500mA
LED100: NCD0603G1; LED0603-RD_1; Manufacturer Part NCD0603G1; LCSC Part Name NCD0603G1
R100, R101: 0Ω; R0402; Manufacturer Part 0402WGF0000TCE; LCSC Part Name 0Ω ±1% 62.5mW 厚膜电阻
R102, R103: 10kΩ; R0402; Manufacturer Part 0402WGF1002TCE; LCSC Part Name 10kΩ ±1% 62.5mW 厚膜电阻
R104: 1kΩ; R0402; Manufacturer Part 0402WGF1001TCE; LCSC Part Name 1kΩ ±1% 62.5mW 厚膜电阻
SW102, SW103: TS3735A 250gf 030; SW-SMD_4P-L3.7-W3.7-P2.70-LS3.7; Manufacturer Part TS3735A 250gf 030; LCSC Part Name 3.7*3.7*0.35mm 立贴 轻触开关
U217: STM32G431CBU6; VQFN-48_L7.0-W7.0-P0.50-BL-EP5.5; Manufacturer Part STM32G431CBU6; LCSC Part Name 带DSP和FPU的170MHz主流ARM Cortex-M4 MCU，具有12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
X100: 8MHz; CRYSTAL-SMD_4P-L3.2-W2.5-BL; Manufacturer Part X32258MSB4SI; LCSC Part Name 8MHz ±10ppm 20pF
X101: 32.768kHz; FC-135R_L3.2-W1.5; Manufacturer Part Q13FC13500004; LCSC Part Name 32.768kHz ±20ppm 12.5pF

Connections:
+3.3V: C157.1, C160.2, C162.2, C163.2, C164.2, C165.2, C166.2, C169.2, FPC102.1, H100.1, R100.1, R101.1, R102.2, R104.1, SW103.1, SW103.2, U217.1 (VBAT), U217.23 (VDD), U217.35 (VDD), U217.48 (VDD)
/ADNS9800_CS: 51.1, FPC102.7
/ADNS9800_MOTION: 41.1, FPC102.8
/BOOT0: R103.2, SW103.3, U217.46 (PB8-BOOT0)
/COL1: 11.1, FPC101.7
/COL2: 21.1, FPC101.6
/COL3: 31.1, FPC101.5
/COL4: 101.1, FPC103.3
/COL5: 111.1, FPC103.4
/COL6: 131.1, FPC103.5
/COL7: 151.1, FPC103.6
/COL8: 91.2, FPC103.7
/ENCODER_A: 221.2, FPC101.2
/ENCODER_B: 211.2, FPC101.1
/NRST: C159.1, R102.1, SW102.4, U217.7 (PG10-NRST)
/OSC32_IN: C170.1, U217.3 (PC14-OSC32_IN), X101.2
/OSC32_OUT: C173.1, U217.4 (PC15-OSC32_OUT), X101.1
/OSC_IN: C172.2, U217.5 (PF0-OSC_IN), X100.3
/OSC_OUT: C171.1, U217.6 (PF1-OSC_OUT), X100.1
/PA0: 11.2, U217.8 (PA0)
/PA1: 21.2, U217.9 (PA1)
/PA2: 31.2, U217.10 (PA2)
/PA3: 41.2, U217.11 (PA3)
/PA4: 51.2, U217.12 (PA4)
/PA5: 61.2, U217.13 (PA5)
/PA6: 71.2, U217.14 (PA6)
/PA7: 81.2, U217.15 (PA7)
/PA8: 231.1, U217.30 (PA8)
/PA9: 221.1, U217.31 (PA9)
/PA10: 211.1, U217.32 (PA10)
/PA15: 201.1, U217.38 (PA15)
/PB0: 111.2, U217.17 (PB0)
/PB1: 131.2, U217.18 (PB1)
/PB2: 151.2, U217.19 (PB2)
/PB3: 161.1, U217.41 (PB3)
/PB4: 141.1, U217.42 (PB4)
/PB5: 121.1, U217.43 (PB5)
/PB7: 91.1, U217.45 (PB7)
/PB10: 191.2, U217.22 (PB10)
/PB12: 281.1, U217.25 (PB12)
/PB13: 271.1, U217.26 (PB13)
/PB14: 261.1, U217.27 (PB14)
/PB15: 251.1, U217.28 (PB15)
/PC4: 101.2, U217.16 (PC4)
/PC6: 241.1, U217.29 (PC6)
/PC10: 181.1, U217.39 (PC10)
/PC11: 171.1, U217.40 (PC11)
/ROW6: 231.2, FPC101.8, FPC103.1
/SPI_MISO: 71.1, FPC102.5
/SPI_MOSI: 81.1, FPC102.4
/SPI_SCK: 61.1, FPC102.6
/SWCLK: H100.4, U217.37 (PA14)
/SWDIO: H100.3, U217.36 (PA13)
/USB_DM: FPC100.2, U217.33 (PA11)
/USB_DP: FPC100.3, U217.34 (PA12)
/VDDA: C161.2, R101.2, U217.21 (VDDA)
/VREF: C158.1, R100.2, U217.20 (VREF+)
GND: C157.2, C158.2, C159.2, C160.1, C161.1, C162.1, C163.1, C164.1, C165.1, C166.1, C168.1, C169.1, C170.2, C171.2, C172.1, C173.2, D159.2 (A), FPC100.1, FPC100.4, FPC100.5, FPC100.9, FPC100.10, FPC101.3, FPC101.4, FPC101.9, FPC101.10, FPC102.2, FPC102.3, FPC102.9, FPC102.10, FPC103.9, FPC103.10, H100.2, LDO100.2 (VSS), LED100.1 (K), R103.1, SW102.1, SW102.2, U217.49 (EP), X100.2 (GND), X100.4 (GND); also elsewhere on the board
unnamed: D159.1 (C), LDO100.5 (VOUT)
unnamed: LED100.2 (A), R104.2
VBUS: 291.2, C167.2 (2_2), C168.2, FPC100.6, FPC100.7, FPC100.8, LDO100.1 (VIN), LDO100.3 (CE)

Notes on the sheet:
One-Handed Keyboard_MR
轨迹球
Type-C
BOOT & RESET

Parts:
C100, C101, C102, C103, C104, C105, C106, C107, C108, C109, C110, C111, C112, C113, C114, C115, C116, C117, C118, C119, C120, C121, C122, C123, C124, C125, C126, C127, C128, C129, C130, C131, C132, C133, C134, C135, C136, C137, C138, C139, C140, C141, C142, C143, C144, C145, C146, C147, C148, C149, C150, C151, C152, C153, C154, C155, C156: 100nF; C0603; Manufacturer Part CC0603KRX7R9BB104; LCSC Part Name 100nF ±10% 50V
D100, D101, D102, D103, D104, D105, D106, D107, D108, D109, D110, D111, D112, D113, D114, D115, D116, D117, D118, D119, D120, D121, D122, D123, D124, D125, D126, D127, D128, D129, D130, D131, D132, D133, D134, D135, D136, D137, D138, D139, D142, D143, D144, D145, D146, D147, D148, D149, D150, D151, D152, D153, D154, D155, D156, D157, D158: 1N4148WS; SOD-323_L1.8-W1.3-LS2.5-RD; Manufacturer Part 1N4148WS; LCSC Part Name 丝印T4
D140, D141: 1N4148WS; SOD-323_L1.8-W1.3-LS2.5-RD; Manufacturer Part 1N4148WS; LCSC Part Name 电压:100V 电流:150mA
SW100, SW101: K9-1267T; SW-TH_K9-1267T; Manufacturer Part K9-1267T; LCSC Part Name 12.7*5.7*7.5mm 插件微动开关
U100, U101, U102, U103, U104, U105, U106, U107, U108, U109, U110, U111, U112, U113, U128, U129, U130, U131, U132, U133, U134, U135, U136, U137, U138, U139, U140, U141, U156, U157, U158, U159, U160, U161, U162, U163, U164, U165, U166, U167, U182, U183, U184, U185, U186, U187, U188, U189, U198, U199, U200, U201, U202, U203, U204, U205, U206: Yo-WS2812B-3528反贴雾状; LED-SMD_L3.2-W2.8_YO-WS2812B-3528; Manufacturer Part Yo-WS2812B-3528反贴雾状; LCSC Part Name Yo-WS2812B-3528反贴雾状
U114, U115, U116, U117, U118, U119, U120, U121, U122, U123, U124, U125, U126, U127, U142, U143, U144, U145, U146, U147, U148, U149, U150, U151, U152, U153, U154, U155, U168, U169, U170, U171, U172, U173, U174, U175, U176, U177, U178, U179, U190, U191, U192, U193, U194, U195, U196, U197, U207, U208, U209, U210, U211, U212, U213, U214, U215: CPG151101S11-16; SMD_KEYBOARD-SW; Manufacturer Part CPG151101S11-16; LCSC Part Name 热插拔底座连接器 键盘配件
U180, U181: XL-3528RGBC-WS2812B; LED-SMD_4P-L3.5-W2.8-BR-1; Manufacturer Part XL-3528RGBC-WS2812B; LCSC Part Name XL-3528RGBC-WS2812B

Connections:
+5V: C100.2, C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C108.2, C109.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, C116.2, C117.2, C118.2, C119.2, C120.2, C121.2, C122.2, C123.2, C124.2, C125.2, C126.2, C127.2, C128.2, C129.2, C130.2, C131.2, C132.2, C133.2, C134.2, C135.2, C136.2, C137.2, C138.2, C139.2, C140.2, C141.2, C142.2, C143.2, C144.2, C145.2, C146.2, C147.2, C148.2, C149.2, C150.2, C151.2, C152.2, C153.2, C154.2, C155.2, C156.2, U100.1 (VDD), U101.1 (VDD), U102.1 (VDD), U103.1 (VDD), U104.1 (VDD), U105.1 (VDD), U106.1 (VDD), U107.1 (VDD), U108.1 (VDD), U109.1 (VDD), U110.1 (VDD), U111.1 (VDD), U112.1 (VDD), U113.1 (VDD), U128.1 (VDD), U129.1 (VDD), U130.1 (VDD), U131.1 (VDD), U132.1 (VDD), U133.1 (VDD), U134.1 (VDD), U135.1 (VDD), U136.1 (VDD), U137.1 (VDD), U138.1 (VDD), U139.1 (VDD), U140.1 (VDD), U141.1 (VDD), U156.1 (VDD), U157.1 (VDD), U158.1 (VDD), U159.1 (VDD), U160.1 (VDD), U161.1 (VDD), U162.1 (VDD), U163.1 (VDD), U164.1 (VDD), U165.1 (VDD), U166.1 (VDD), U167.1 (VDD), U180.3 (VDD), U181.3 (VDD), U182.1 (VDD), U183.1 (VDD), U184.1 (VDD), U185.1 (VDD), U186.1 (VDD), U187.1 (VDD), U188.1 (VDD), U189.1 (VDD), U198.1 (VDD), U199.1 (VDD), U200.1 (VDD), U201.1 (VDD), U202.1 (VDD), U203.1 (VDD), U204.1 (VDD), U205.1 (VDD), U206.1 (VDD)
COL1: D100.1 (K), D114.1 (K), D128.1 (K), D140.1 (C), D150.1 (K)
COL2: D101.1 (K), D115.1 (K), D129.1 (K)
COL3: D102.1 (K), D116.1 (K), D130.1 (K), D141.1 (C), D151.1 (K)
COL4: D103.1 (K), D117.1 (K), D131.1 (K), D142.1 (K), D152.1 (K)
COL5: D104.1 (K), D118.1 (K)
COL6: D105.1 (K), D119.1 (K), D132.1 (K), D143.1 (K), D153.1 (K)
COL7: D106.1 (K), D120.1 (K), D133.1 (K), D144.1 (K)
COL8: D107.1 (K), D121.1 (K), D134.1 (K), D145.1 (K), D154.1 (K)
COL9: D108.1 (K), D122.1 (K), D135.1 (K)
COL10: D109.1 (K), D123.1 (K), D136.1 (K), D146.1 (K), D155.1 (K)
COL11: D110.1 (K), D124.1 (K), D137.1 (K), D147.1 (K), D156.1 (K)
COL12: D111.1 (K), D125.1 (K), D138.1 (K), D148.1 (K)
COL13: D112.1 (K), D126.1 (K), D157.1 (K)
COL14: D113.1 (K), D127.1 (K), D139.1 (K), D149.1 (K), D158.1 (K)
GND: C100.1, C101.1, C102.1, C103.1, C104.1, C105.1, C106.1, C107.1, C108.1, C109.1, C110.1, C111.1, C112.1, C113.1, C114.1, C115.1, C116.1, C117.1, C118.1, C119.1, C120.1, C121.1, C122.1, C123.1, C124.1, C125.1, C126.1, C127.1, C128.1, C129.1, C130.1, C131.1, C132.1, C133.1, C134.1, C135.1, C136.1, C137.1, C138.1, C139.1, C140.1, C141.1, C142.1, C143.1, C144.1, C145.1, C146.1, C147.1, C148.1, C149.1, C150.1, C151.1, C152.1, C153.1, C154.1, C155.1, C156.1, U100.3 (GND), U101.3 (GND), U102.3 (GND), U103.3 (GND), U104.3 (GND), U105.3 (GND), U106.3 (GND), U107.3 (GND), U108.3 (GND), U109.3 (GND), U110.3 (GND), U111.3 (GND), U112.3 (GND), U113.3 (GND), U128.3 (GND), U129.3 (GND), U130.3 (GND), U131.3 (GND), U132.3 (GND), U133.3 (GND), U134.3 (GND), U135.3 (GND), U136.3 (GND), U137.3 (GND), U138.3 (GND), U139.3 (GND), U140.3 (GND), U141.3 (GND), U156.3 (GND), U157.3 (GND), U158.3 (GND), U159.3 (GND), U160.3 (GND), U161.3 (GND), U162.3 (GND), U163.3 (GND), U164.3 (GND), U165.3 (GND), U166.3 (GND), U167.3 (GND), U180.1 (GND), U181.1 (GND), U182.3 (GND), U183.3 (GND), U184.3 (GND), U185.3 (GND), U186.3 (GND), U187.3 (GND), U188.3 (GND), U189.3 (GND), U198.3 (GND), U199.3 (GND), U200.3 (GND), U201.3 (GND), U202.3 (GND), U203.3 (GND), U204.3 (GND), U205.3 (GND), U206.3 (GND); also elsewhere on the board
unnamed: D100.2 (A), U114.2
unnamed: D101.2 (A), U115.2
unnamed: D102.2 (A), U116.2
unnamed: D103.2 (A), U117.2
unnamed: D104.2 (A), U118.2
unnamed: D105.2 (A), U119.2
unnamed: D106.2 (A), U120.2
unnamed: D107.2 (A), U121.2
unnamed: D108.2 (A), U122.2
unnamed: D109.2 (A), U123.2
unnamed: D110.2 (A), U124.2
unnamed: D111.2 (A), U125.2
unnamed: D112.2 (A), U126.2
unnamed: D113.2 (A), U127.2
unnamed: D114.2 (A), U142.2
unnamed: D115.2 (A), U143.2
unnamed: D116.2 (A), U144.2
unnamed: D117.2 (A), U145.2
unnamed: D118.2 (A), U146.2
unnamed: D119.2 (A), U147.2
unnamed: D120.2 (A), U148.2
unnamed: D121.2 (A), U149.2
unnamed: D122.2 (A), U150.2
unnamed: D123.2 (A), U151.2
unnamed: D124.2 (A), U152.2
unnamed: D125.2 (A), U153.2
unnamed: D126.2 (A), U154.2
unnamed: D127.2 (A), U155.2
unnamed: D128.2 (A), U168.2
unnamed: D129.2 (A), U169.2
unnamed: D130.2 (A), U170.2
unnamed: D131.2 (A), U171.2
unnamed: D132.2 (A), U172.2
unnamed: D133.2 (A), U173.2
unnamed: D134.2 (A), U174.2
unnamed: D135.2 (A), U175.2
unnamed: D136.2 (A), U176.2
unnamed: D137.2 (A), U177.2
unnamed: D138.2 (A), U178.2
unnamed: D139.2 (A), U179.2
unnamed: D140.2 (A), SW100.3 (NC)
unnamed: D141.2 (A), SW101.3 (NC)
unnamed: D142.2 (A), U190.2
unnamed: D143.2 (A), U191.2
unnamed: D144.2 (A), U192.2
unnamed: D145.2 (A), U193.2
unnamed: D146.2 (A), U194.2
unnamed: D147.2 (A), U195.2
unnamed: D148.2 (A), U196.2
unnamed: D149.2 (A), U197.2
unnamed: D150.2 (A), U207.2
unnamed: D151.2 (A), U208.2
unnamed: D152.2 (A), U209.2
unnamed: D153.2 (A), U210.2
unnamed: D154.2 (A), U211.2
unnamed: D155.2 (A), U212.2
unnamed: D156.2 (A), U213.2
unnamed: D157.2 (A), U214.2
unnamed: D158.2 (A), U215.2
unnamed: U100.2 (DOUT), U101.4 (DIN)
unnamed: U101.2 (DOUT), U102.4 (DIN)
unnamed: U102.2 (DOUT), U103.4 (DIN)
unnamed: U103.2 (DOUT), U104.4 (DIN)
unnamed: U104.2 (DOUT), U105.4 (DIN)
unnamed: U105.2 (DOUT), U106.4 (DIN)
unnamed: U106.2 (DOUT), U107.4 (DIN)
unnamed: U107.2 (DOUT), U108.4 (DIN)
unnamed: U108.2 (DOUT), U109.4 (DIN)
unnamed: U109.2 (DOUT), U110.4 (DIN)
unnamed: U110.2 (DOUT), U111.4 (DIN)
unnamed: U111.2 (DOUT), U112.4 (DIN)
unnamed: U112.2 (DOUT), U113.4 (DIN)
unnamed: U128.2 (DOUT), U129.4 (DIN)
unnamed: U129.2 (DOUT), U130.4 (DIN)
unnamed: U130.2 (DOUT), U131.4 (DIN)
unnamed: U131.2 (DOUT), U132.4 (DIN)
unnamed: U132.2 (DOUT), U133.4 (DIN)
unnamed: U133.2 (DOUT), U134.4 (DIN)
unnamed: U134.2 (DOUT), U135.4 (DIN)
unnamed: U135.2 (DOUT), U136.4 (DIN)
unnamed: U136.2 (DOUT), U137.4 (DIN)
unnamed: U137.2 (DOUT), U138.4 (DIN)
unnamed: U138.2 (DOUT), U139.4 (DIN)
unnamed: U139.2 (DOUT), U140.4 (DIN)
unnamed: U140.2 (DOUT), U141.4 (DIN)
unnamed: U156.2 (DOUT), U157.4 (DIN)
unnamed: U157.2 (DOUT), U158.4 (DIN)
unnamed: U158.2 (DOUT), U159.4 (DIN)
unnamed: U159.2 (DOUT), U160.4 (DIN)
unnamed: U160.2 (DOUT), U161.4 (DIN)
unnamed: U161.2 (DOUT), U162.4 (DIN)
unnamed: U162.2 (DOUT), U163.4 (DIN)
unnamed: U163.2 (DOUT), U164.4 (DIN)
unnamed: U164.2 (DOUT), U165.4 (DIN)
unnamed: U165.2 (DOUT), U166.4 (DIN)
unnamed: U166.2 (DOUT), U167.4 (DIN)
unnamed: U180.4 (DO), U181.2 (DI)
unnamed: U181.4 (DO), U182.4 (DIN)
unnamed: U182.2 (DOUT), U183.4 (DIN)
unnamed: U183.2 (DOUT), U184.4 (DIN)
unnamed: U184.2 (DOUT), U185.4 (DIN)
unnamed: U185.2 (DOUT), U186.4 (DIN)
unnamed: U186.2 (DOUT), U187.4 (DIN)
unnamed: U187.2 (DOUT), U188.4 (DIN)
unnamed: U188.2 (DOUT), U189.4 (DIN)
unnamed: U198.2 (DOUT), U199.4 (DIN)
unnamed: U199.2 (DOUT), U200.4 (DIN)
unnamed: U200.2 (DOUT), U201.4 (DIN)
unnamed: U201.2 (DOUT), U202.4 (DIN)
unnamed: U202.2 (DOUT), U203.4 (DIN)
unnamed: U203.2 (DOUT), U204.4 (DIN)
unnamed: U204.2 (DOUT), U205.4 (DIN)
unnamed: U205.2 (DOUT), U206.4 (DIN)
ROW1: U114.1, U115.1, U116.1, U117.1, U118.1, U119.1, U120.1, U121.1, U122.1, U123.1, U124.1, U125.1, U126.1, U127.1
ROW2: U142.1, U143.1, U144.1, U145.1, U146.1, U147.1, U148.1, U149.1, U150.1, U151.1, U152.1, U153.1, U154.1, U155.1
ROW3: U168.1, U169.1, U170.1, U171.1, U172.1, U173.1, U174.1, U175.1, U176.1, U177.1, U178.1, U179.1
ROW4: SW100.2 (ON), SW101.2 (ON), U190.1, U191.1, U192.1, U193.1, U194.1, U195.1, U196.1, U197.1
ROW5: U207.1, U208.1, U209.1, U210.1, U211.1, U212.1, U213.1, U214.1, U215.1
WS2812_1: U100.4 (DIN)
WS2812_2: U113.2 (DOUT), U128.4 (DIN)
WS2812_3: U141.2 (DOUT), U156.4 (DIN)
WS2812_4: U167.2 (DOUT), U180.2 (DI)
WS2812_5: U189.2 (DOUT), U198.4 (DIN)

Board: 4 copper layers, 257.8 x 110.7 mm, 269 parts (247 on the bottom side), 155 nets.
